# IAR project ControlConsole.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208R8 STM8S208R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\File\IRAProject\一体式操控台_IAR\Lib\inc; D:\File\IRAProject\一体式操控台_IAR\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ControlConsole.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c spi_user.c stm8s_conf.h w5500.c
    ../Lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_spi.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c
  group lib
    ../Lib/inc/: stm8s.h
